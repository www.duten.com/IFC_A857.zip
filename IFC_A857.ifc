Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-09-14T16:59:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 14 16:59:26 2021 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{C78FFF33-198D-493B-B577-A82482DE834F}\ifc * Database version: 5507 * Database creation date: Tue Sep 14 16:59:25 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 14 16:59:25 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 14 16:59:25 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: Brushed Stainless Steel Free Flow Waste, Duten_WstsForWshBsns_A857:Brushed Stainless Steel Free Flow Waste:314048
In: Level 0
Type - ElementType: Brushed Stainless Steel Free Flow Waste; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_White
Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel Free Flow Waste; Manufacturer: Duten

# IfcFurnishingElement: Matte Black Free Flow Waste, Duten_WstsForWshBsns_A857:Matte Black Free Flow Waste:314051
In: Level 0
Type - ElementType: Matte Black Free Flow Waste; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_MatteBlack, Duten_Plastic_White
Pset_ManufacturerTypeInformation - ModelReference: Matte Black Free Flow Waste; Manufacturer: Duten

# IfcFurnishingElement: Polished Stainless Steel Free Flow Waste, Duten_WstsForWshBsns_A857:Polished Stainless Steel Free Flow Waste:314054
In: Level 0
Type - ElementType: Polished Stainless Steel Free Flow Waste; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_Polished, Duten_Plastic_White
Pset_ManufacturerTypeInformation - ModelReference: Polished Stainless Steel Free Flow Waste; Manufacturer: Duten
